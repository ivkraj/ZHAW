# IAR project timer_output_compare_pg.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG1B200F256GM48 SiliconLaboratories EFM32PG1B200F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32PG1B200F256GM48; STK3401
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Include; ..\..\..\Device\SiliconLabs\EFM32PG\Include; ..\..\..\emlib\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFM32PG1B200F256GM48; STK3401
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: timer_output_compare_pg.bin
  ILINK.IlinkOutputFile: timer_output_compare_pg.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32PG1B200F256GM48; STK3401
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../Device/SiliconLabs/EFM32PG/Source/IAR/: startup_efm32pg.s
    ../../../Device/SiliconLabs/EFM32PG/Source/: system_efm32pg.c
  group emlib
    ../../../emlib/src/: em_cmu.c em_emu.c em_gpio.c em_system.c em_timer.c
  group Source
    ../: main_timer_output_compare.c
