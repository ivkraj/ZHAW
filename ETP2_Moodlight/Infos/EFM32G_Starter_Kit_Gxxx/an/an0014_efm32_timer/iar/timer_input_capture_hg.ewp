# IAR project timer_input_capture_hg.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32HG322F64 SiliconLaboratories EFM32HG322F64
  ICCARM.CCDefines: EFM32HG322F64; STK3400; MEMORY_LCD
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Include; ..\..\..\Device\SiliconLabs\EFM32HG\Include; ..\..\..\emlib\inc; ..\..\..\an\an0014_efm32_timer; ..\..\..\reptile\glib; ..\..\..\kits\SLSTK3400A_EFM32HG\config; ..\..\..\kits\common\bsp; ..\..\..\kits\common\drivers; ..\..\..\kits\SLSTK3400A_EFM32HG\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32HG322F64; STK3400; MEMORY_LCD
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: timer_input_capture_hg.bin
  ILINK.IlinkOutputFile: timer_input_capture_hg.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32HG322F64; STK3400; MEMORY_LCD
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../Device/SiliconLabs/EFM32HG/Source/IAR/: startup_efm32hg.s
    ../../../Device/SiliconLabs/EFM32HG/Source/: system_efm32hg.c
  group Drivers
    ../../../kits/common/drivers/: display.c displayls013b7dh03.c displaypalemlib.c retargetio.c retargettextdisplay.c textdisplay.c udelay.c
  group emlib
    ../../../emlib/src/: em_cmu.c em_emu.c em_core.c em_gpio.c em_lcd.c em_prs.c em_system.c em_timer.c em_rtc.c em_usart.c
  group Source
    ../: main_timer_input_capture.c
