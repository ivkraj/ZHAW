# IAR project timer_output_compare_gecko.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32G890F128 SiliconLaboratories EFM32G890F128
  ICCARM.CCDefines: EFM32G890F128; STKG8XX
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Include; ..\..\..\Device\SiliconLabs\EFM32G\Include; ..\..\..\emlib\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32G890F128; STKG8XX
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: timer_output_compare_gecko.bin
  ILINK.IlinkOutputFile: timer_output_compare_gecko.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32G890F128; STKG8XX
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../Device/SiliconLabs/EFM32G/Source/IAR/: startup_efm32g.s
    ../../../Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group emlib
    ../../../emlib/src/: em_cmu.c em_emu.c em_gpio.c em_system.c em_timer.c
  group Source
    ../: main_timer_output_compare.c
