<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\timer_up_count_gecko.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_quad_decode_gecko.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_input_capture_gecko.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_input_capture_dma_gecko.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_output_compare_gecko.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_pwm_gecko.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_pwm_dma_gecko.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_up_count_tg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_input_capture_tg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_input_capture_dma_tg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_output_compare_tg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_pwm_tg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_pwm_dma_tg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_up_count_gg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_input_capture_gg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_input_capture_dma_gg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_output_compare_gg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_pwm_gg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_pwm_dma_gg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_up_count_lg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_input_capture_lg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_input_capture_dma_lg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_output_compare_lg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_pwm_lg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_pwm_dma_lg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_up_count_hg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_input_capture_hg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_input_capture_dma_hg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_output_compare_hg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_pwm_hg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_pwm_dma_hg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_up_count_zg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_input_capture_zg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_input_capture_dma_zg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_output_compare_zg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_pwm_zg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_pwm_dma_zg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_up_count_pg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_input_capture_pg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_input_capture_ldma_pg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_output_compare_pg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_pwm_pg.ewp</path>
  </project>

  <batchBuild/>
</workspace>
