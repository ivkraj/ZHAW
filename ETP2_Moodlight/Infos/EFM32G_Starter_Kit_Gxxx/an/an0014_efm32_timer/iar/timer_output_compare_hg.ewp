# IAR project timer_output_compare_hg.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32HG322F64 SiliconLaboratories EFM32HG322F64
  ICCARM.CCDefines: EFM32HG322F64; STK3400
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Include; ..\..\..\Device\SiliconLabs\EFM32HG\Include; ..\..\..\emlib\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32HG322F64; STK3400
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: timer_output_compare_hg.bin
  ILINK.IlinkOutputFile: timer_output_compare_hg.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32HG322F64; STK3400
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../Device/SiliconLabs/EFM32HG/Source/IAR/: startup_efm32hg.s
    ../../../Device/SiliconLabs/EFM32HG/Source/: system_efm32hg.c
  group emlib
    ../../../emlib/src/: em_cmu.c em_emu.c em_gpio.c em_system.c em_timer.c
  group Source
    ../: main_timer_output_compare.c
