# IAR project timer_input_capture_ldma_pg.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG1B200F256GM48 SiliconLaboratories EFM32PG1B200F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32PG1B200F256GM48; STK3401
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Include; ..\..\..\Device\SiliconLabs\EFM32PG\Include; ..\..\..\emlib\inc; ..\..\..\kits\common\bsp; ..\..\..\kits\common\drivers; ..\..\..\kits\SLSTK3401A_EFM32PG\config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFM32PG1B200F256GM48; STK3401
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: timer_input_capture_ldma_pg.bin
  ILINK.IlinkOutputFile: timer_input_capture_ldma_pg.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32PG1B200F256GM48; STK3401
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../Device/SiliconLabs/EFM32PG/Source/IAR/: startup_efm32pg.s
    ../../../Device/SiliconLabs/EFM32PG/Source/: system_efm32pg.c
  group Drivers
    ../../../kits/common/drivers/: dmactrl.c
  group emlib
    ../../../emlib/src/: em_cmu.c em_emu.c em_core.c em_ldma.c em_gpio.c em_prs.c em_system.c em_timer.c
  group Source
    ../: main_timer_input_capture_ldma.c
