# Keil uVision project timer_input_capture_gecko.uvprojx, settings and files
target timer_input_capture_gecko (ARM-ADS)
  device: EFM32G890F128 Silicon Labs
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: timer_input_capture_gecko
  AfterMake: fromelf.exe --bin --output obj\timer_input_capture_gecko.bin obj\timer_input_capture_gecko.axf
  c flags: Optim=1 oTime=1
  c define: EFM32G890F128 STKG8XX
  c misc: --c99
  c include: ..\;..\..\..\CMSIS\Include;..\..\..\Device\SiliconLabs\EFM32G\Include;..\..\..\emlib\inc;..\..\..\kits\common\bsp;..\..\..\kits\common\drivers;..\..\..\kits\EFM32_Gxxx_STK\config
  asm define: EFM32G890F128 STKG8XX
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../../../Device/SiliconLabs/EFM32G/Source/ARM/: startup_efm32g.s
    ../../../Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group Drivers
    ../../../kits/common/drivers/: segmentlcd.c
  group emlib
    ../../../emlib/src/: em_cmu.c em_core.c em_emu.c em_gpio.c em_lcd.c em_prs.c em_system.c em_timer.c
  group Source
    ../: main_timer_input_capture.c
