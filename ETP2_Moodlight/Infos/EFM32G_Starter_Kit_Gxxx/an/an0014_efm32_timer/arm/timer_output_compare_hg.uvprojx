# Keil uVision project timer_output_compare_hg.uvprojx, settings and files
target timer_output_compare_hg (ARM-ADS)
  device: EFM32HG322F64 Silicon Labs
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(24000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: timer_output_compare_hg
  AfterMake: fromelf.exe --bin --output obj\timer_output_compare_hg.bin obj\timer_output_compare_hg.axf
  c flags: Optim=1 oTime=1
  c define: EFM32HG322F64 STK3400
  c misc: --c99
  c include: ..\;..\..\..\CMSIS\Include;..\..\..\Device\SiliconLabs\EFM32HG\Include;..\..\..\emlib\inc
  asm define: EFM32HG322F64 STK3400
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../../Device/SiliconLabs/EFM32HG/Source/ARM/: startup_efm32hg.s
    ../../../Device/SiliconLabs/EFM32HG/Source/: system_efm32hg.c
  group emlib
    ../../../emlib/src/: em_cmu.c em_emu.c em_gpio.c em_system.c em_timer.c
  group Source
    ../: main_timer_output_compare.c
