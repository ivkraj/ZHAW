# Keil uVision project timer_input_capture_pg.uvprojx, settings and files
target timer_input_capture_pg (ARM-ADS)
  device: EFM32PG1B200F256GM48 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(38400000) CPUTYPE("Cortex-M4") FPU2
  output: timer_input_capture_pg
  AfterMake: fromelf.exe --bin --output obj\timer_input_capture_pg.bin obj\timer_input_capture_pg.axf
  c flags: Optim=1 oTime=1 uC99=1 wLevel=2
  c define: EFM32PG1B200F256GM48 STK3401 MEMORY_LCD
  c include: ..\;..\..\..\CMSIS\Include;..\..\..\Device\SiliconLabs\EFM32PG\Include;..\..\..\emlib\inc;..\..\..\an\an0014_efm32_timer;..\..\..\reptile\glib;..\..\..\kits\SLSTK3401A_EFM32PG\config;..\..\..\kits\common\bsp;..\..\..\kits\common\drivers;..\..\..\kits\SLSTK3401A_EFM32PG\config
  asm define: EFM32PG1B200F256GM48 STK3401 MEMORY_LCD
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../Device/SiliconLabs/EFM32PG/Source/ARM/: startup_efm32pg.s
    ../../../Device/SiliconLabs/EFM32PG/Source/: system_efm32pg.c
  group Drivers
    ../../../kits/common/drivers/: display.c displayls013b7dh03.c displaypalemlib.c retargetio.c retargettextdisplay.c textdisplay.c udelay.c
  group emlib
    ../../../emlib/src/: em_cmu.c em_emu.c em_core.c em_gpio.c em_lcd.c em_prs.c em_system.c em_timer.c em_rtcc.c em_usart.c
  group Source
    ../: main_timer_input_capture.c
