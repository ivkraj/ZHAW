# Keil uVision project timer_input_capture_lg.uvprojx, settings and files
target timer_input_capture_lg (ARM-ADS)
  device: EFM32LG990F256 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: timer_input_capture_lg
  AfterMake: fromelf.exe --bin --output obj\timer_input_capture_lg.bin obj\timer_input_capture_lg.axf
  c flags: Optim=1 oTime=1
  c define: EFM32LG990F256 STK3600
  c misc: --c99
  c include: ..\;..\..\..\CMSIS\Include;..\..\..\Device\SiliconLabs\EFM32LG\Include;..\..\..\emlib\inc;..\..\..\kits\common\bsp;..\..\..\kits\common\drivers;..\..\..\kits\EFM32LG_STK3600\config
  asm define: EFM32LG990F256 STK3600
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../Device/SiliconLabs/EFM32LG/Source/ARM/: startup_efm32lg.s
    ../../../Device/SiliconLabs/EFM32LG/Source/: system_efm32lg.c
  group Drivers
    ../../../kits/common/drivers/: segmentlcd.c
  group emlib
    ../../../emlib/src/: em_cmu.c em_core.c em_emu.c em_gpio.c em_lcd.c em_prs.c em_system.c em_timer.c
  group Source
    ../: main_timer_input_capture.c
