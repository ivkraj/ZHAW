# Keil uVision project timer_input_capture_dma_gg.uvprojx, settings and files
target timer_input_capture_dma_gg (ARM-ADS)
  device: EFM32GG990F1024 Silicon Labs
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: timer_input_capture_dma_gg
  AfterMake: fromelf.exe --bin --output obj\timer_input_capture_dma_gg.bin obj\timer_input_capture_dma_gg.axf
  c flags: Optim=1 oTime=1
  c define: EFM32GG990F1024 STK3700
  c misc: --c99
  c include: ..\;..\..\..\CMSIS\Include;..\..\..\Device\SiliconLabs\EFM32GG\Include;..\..\..\emlib\inc;..\..\..\kits\common\bsp;..\..\..\kits\common\drivers;..\..\..\kits\EFM32GG_STK3700\config
  asm define: EFM32GG990F1024 STK3700
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../../Device/SiliconLabs/EFM32GG/Source/ARM/: startup_efm32gg.s
    ../../../Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group Drivers
    ../../../kits/common/drivers/: dmactrl.c
  group emlib
    ../../../emlib/src/: em_cmu.c em_emu.c em_dma.c em_gpio.c em_prs.c em_system.c em_timer.c
  group Source
    ../: main_timer_input_capture_dma.c
