# Keil uVision project timer_input_capture_hg.uvprojx, settings and files
target timer_input_capture_hg (ARM-ADS)
  device: EFM32HG322F64 Silicon Labs
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(24000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: timer_input_capture_hg
  AfterMake: fromelf.exe --bin --output obj\timer_input_capture_hg.bin obj\timer_input_capture_hg.axf
  c flags: Optim=1 oTime=1
  c define: EFM32HG322F64 STK3400 MEMORY_LCD
  c misc: --c99
  c include: ..\;..\..\..\CMSIS\Include;..\..\..\Device\SiliconLabs\EFM32HG\Include;..\..\..\emlib\inc;..\..\..\an\an0014_efm32_timer;..\..\..\reptile\glib;..\..\..\kits\SLSTK3400A_EFM32HG\config;..\..\..\kits\common\bsp;..\..\..\kits\common\drivers;..\..\..\kits\SLSTK3400A_EFM32HG\config
  asm define: EFM32HG322F64 STK3400 MEMORY_LCD
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../../Device/SiliconLabs/EFM32HG/Source/ARM/: startup_efm32hg.s
    ../../../Device/SiliconLabs/EFM32HG/Source/: system_efm32hg.c
  group Drivers
    ../../../kits/common/drivers/: display.c displayls013b7dh03.c displaypalemlib.c retargetio.c retargettextdisplay.c textdisplay.c udelay.c
  group emlib
    ../../../emlib/src/: em_cmu.c em_emu.c em_core.c em_gpio.c em_lcd.c em_prs.c em_system.c em_timer.c em_rtc.c em_usart.c
  group Source
    ../: main_timer_input_capture.c
