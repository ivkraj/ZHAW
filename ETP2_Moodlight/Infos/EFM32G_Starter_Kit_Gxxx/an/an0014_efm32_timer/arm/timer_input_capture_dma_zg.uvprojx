# Keil uVision project timer_input_capture_dma_zg.uvprojx, settings and files
target timer_input_capture_dma_zg (ARM-ADS)
  device: EFM32ZG222F32 Silicon Labs
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(24000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: timer_input_capture_dma_zg
  AfterMake: fromelf.exe --bin --output obj\timer_input_capture_dma_zg.bin obj\timer_input_capture_dma_zg.axf
  c flags: Optim=1 oTime=1
  c define: EFM32ZG222F32 STK3200
  c misc: --c99
  c include: ..\;..\..\..\CMSIS\Include;..\..\..\Device\SiliconLabs\EFM32ZG\Include;..\..\..\emlib\inc;..\..\..\kits\common\bsp;..\..\..\kits\common\drivers;..\..\..\kits\EFM32ZG_STK3200\config
  asm define: EFM32ZG222F32 STK3200
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../../Device/SiliconLabs/EFM32ZG/Source/ARM/: startup_efm32zg.s
    ../../../Device/SiliconLabs/EFM32ZG/Source/: system_efm32zg.c
  group Drivers
    ../../../kits/common/drivers/: dmactrl.c
  group emlib
    ../../../emlib/src/: em_cmu.c em_emu.c em_dma.c em_gpio.c em_prs.c em_system.c em_timer.c
  group Source
    ../: main_timer_input_capture_dma.c
