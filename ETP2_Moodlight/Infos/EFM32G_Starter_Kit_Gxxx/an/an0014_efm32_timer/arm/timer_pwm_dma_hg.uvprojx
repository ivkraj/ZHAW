# Keil uVision project timer_pwm_dma_hg.uvprojx, settings and files
target timer_pwm_dma_hg (ARM-ADS)
  device: EFM32HG322F64 Silicon Labs
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(24000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: timer_pwm_dma_hg
  AfterMake: fromelf.exe --bin --output obj\timer_pwm_dma_hg.bin obj\timer_pwm_dma_hg.axf
  c flags: Optim=1 oTime=1
  c define: EFM32HG322F64 STK3400
  c misc: --c99
  c include: ..\;..\..\..\CMSIS\Include;..\..\..\Device\SiliconLabs\EFM32HG\Include;..\..\..\emlib\inc;..\..\..\kits\common\drivers
  asm define: EFM32HG322F64 STK3400
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../../Device/SiliconLabs/EFM32HG/Source/ARM/: startup_efm32hg.s
    ../../../Device/SiliconLabs/EFM32HG/Source/: system_efm32hg.c
  group Drivers
    ../../../kits/common/drivers/: dmactrl.c
  group emlib
    ../../../emlib/src/: em_cmu.c em_emu.c em_gpio.c em_prs.c em_dma.c em_system.c em_timer.c
  group Source
    ../: main_timer_pwm_dma.c
