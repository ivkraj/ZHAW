# Keil uVision project timer_input_capture_dma_tg.uvprojx, settings and files
target timer_input_capture_dma_tg (ARM-ADS)
  device: EFM32TG840F32 Silicon Labs
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: timer_input_capture_dma_tg
  AfterMake: fromelf.exe --bin --output obj\timer_input_capture_dma_tg.bin obj\timer_input_capture_dma_tg.axf
  c flags: Optim=1 oTime=1
  c define: EFM32TG840F32 STK3300
  c misc: --c99
  c include: ..\;..\..\..\CMSIS\Include;..\..\..\Device\SiliconLabs\EFM32TG\Include;..\..\..\emlib\inc;..\..\..\kits\common\bsp;..\..\..\kits\common\drivers;..\..\..\kits\EFM32TG_STK3300\config
  asm define: EFM32TG840F32 STK3300
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../../Device/SiliconLabs/EFM32TG/Source/ARM/: startup_efm32tg.s
    ../../../Device/SiliconLabs/EFM32TG/Source/: system_efm32tg.c
  group Drivers
    ../../../kits/common/drivers/: dmactrl.c
  group emlib
    ../../../emlib/src/: em_cmu.c em_emu.c em_dma.c em_gpio.c em_prs.c em_system.c em_timer.c
  group Source
    ../: main_timer_input_capture_dma.c
