# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: CT_Board_HS14_M4 STMicroelectronics
  pack: InES.CTBoard14_DFP.4.0.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress 6314
  group App
    ./App/: button_count.c buttons.c egg_timer.c egg_timer_ctrl.c lcd.c main.c mode_control.c observable.c queue.c reload.c reload_ctrl.c scheduler.c seg7_display.c stop_watch.c stop_watch_ctrl.c time.c
software components: Device:Startup 4.0.0, HAL:CT Board:LCD 3.0.3, HAL:FMC 3.0.1, HAL:GPIO 3.0.3, HAL:PWR 2.2.0, HAL:RCC 3.0.1, HAL:SYSTICK 2.2.0
