# Keil uVision project Cooperative.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: CT_Board_HS14_M4 STMicroelectronics
  pack: InES.CTBoard14_DFP.4.0.2
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Cooperative
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NO_FMC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress 6314
  group App
    ../App/: main.c threads_cooperative.c uart.c
software components: CMSIS:RTOS:Keil RTX 4.82.0, Device:Startup 4.0.1, HAL:FMC 3.0.1, HAL:GPIO 4.0.1, HAL:PWR 2.2.0, HAL:RCC 4.0.1, Compiler:I/O:STDOUT 1.2.0
